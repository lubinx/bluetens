# Keil uVision project tens.uvprojx, settings and files
target bluetens (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: QN902X_bluetens
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=4 wLevel=2
  c include: ./;./bluetens;../ultracore/inc;../qn902x
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ../qn902x/mdk\qn902x.sct
  group main
    ./: common_config.h fstab.h fstab.c loki.hpp loki.cpp main.cpp app.hpp app.cpp notification.h test_50hz.lok
  group shell
    ./sh/: shell.hpp shell.cpp shell.ctrl.cpp shell.ota.cpp shell.file.cpp
  group bluetens
    ./bluetens/: config.h QN902X_config.h ble.hpp bluetens.cpp
  group duosport
    ./duosport/: config.h QN902X_config.h ble.hpp duosport.cpp
  group fitsuit
    ./fitsuit/: config.h QN902X_config.h ble.hpp fitsuit.cpp
  group cablemagic
    ./cablemagic/: config.h QN902X_config.h ble.hpp cablemagic.cpp
  group bluetens 2
    ./bluetens2/: config.h ble.hpp BG22_porting.h EFR32_config.h EFR32_PIN_config.h QN908X_porting.h QN908X_config.h bluetens2.cpp
  group qn902x
    ../qn902x/: QN902x_startup.c QN902x_system.c rw.soc.cpp adc.c flash.c gpio.c pwm.c rtc.c timer.c uart.c
    ../ultracore/src/hash/: crc_ccitt_no_xlat.c
    ../qn902x/mdk/: qn9020b2_lib_peripheral.1.3.5.lib
    ../ultracore/lib/: lib_ultracore_armv6m_mdk.lib
  group qn908x
    ../qn908x/: QN908XC_startup.c QN908XC_system.c nxp.ble.cpp pmu.c adc.c trng.c calibration.c flexcomm.c fsp.c inpmux.c gpio.c radio.c rtc.c sct.c flash.c timer.c uart.c
    ../ultracore/lib/: lib_ultracore_mdk_qn908x.lib
    ../qn908x/mdk/: bluetooth_1_5_5.symdefs
  group BG22
    ../efr32xg22/: EFR32_system.c EFR32_startup.c adc.c rtc.c gpio.c pmu.c flash.c timer.c uart.c sl.bluetooth.cpp
    ../efr32xg22/sdk/: libbluetooth.a
    ../efr32xg22/gcc/: lib_xg22sdk_gcc.a
    ../ultracore/lib/: libultracore_armv7-fpv4-sp-d16.a
target duosport (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: QN902X_duosport
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=4 wLevel=2
  c include: ./;./duosport;../ultracore/inc;../qn902x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ../qn902x/mdk\qn902x.sct
target fitsuit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: fitsuit
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=4 wLevel=2
  c include: ./;./fitsuit;../ultracore/inc;../qn902x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ../qn902x/mdk\qn902x.sct
target cablemagic (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: cablemagic
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=4 wLevel=2
  c include: ./;./cablemagic;../ultracore/inc;../qn902x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ../qn902x/mdk\qn902x.sct
target 908X_bluetens (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: QN9080C NXP
  pack: NXP.QN908x_DFP.1.1.5
  cpu: IRAM(0x04000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QN908X_bluetens
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: QN908X,BLUETENS2
  c misc: --no_wchar
  c include: .\;.\bluetens2;..\ultracore\inc;..\qn908x\include;..\qn908x\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x4000000 size 0x20000
  scatter file: ../qn908x/mdk\qn908x.sct
target 908X_duosport (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: QN9080C NXP
  pack: NXP.QN908x_DFP.1.1.5
  cpu: as above
  output: QN908X_duosport
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: QN908X,DUOSPORT2
  c misc: --no_wchar
  c include: ./;./bluetens2;../ultracore/inc;../qn908x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x4000000 size 0x20000
  scatter file: ../qn908x/mdk\qn908x.sct
target 908X_pinktens (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: QN9080C NXP
  pack: NXP.QN908x_DFP.1.1.5
  cpu: as above
  output: QN908X_pinktens
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: QN908X,PINKTENS
  c misc: --no_wchar
  c include: ./;./bluetens2;../ultracore/inc;../qn908x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x4000000 size 0x20000
  scatter file: ../qn908x/mdk\qn908x.sct
target 908X_medtens (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: QN9080C NXP
  pack: NXP.QN908x_DFP.1.1.5
  cpu: as above
  output: QN908X_medtens
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: QN908X,MEDTENS
  c misc: --no_wchar
  c include: ./;./bluetens2;../ultracore/inc;../qn908x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x4000000 size 0x20000
  scatter file: ../qn908x/mdk\qn908x.sct
target BG22_bluetens (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: EFR32BG22C224F512GM40 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFR32BG22_DFP.4.4.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: BG22_bluetens
  AfterMake: C:\gnu\arm\10 2021.10\bin\arm-none-eabi-size "#L.elf" -A
  AfterMake: C:\gnu\arm\10 2021.10\bin\arm-none-eabi-objcopy -O binary "#L".elf "..\_bin\@L.bin"
target BG22_duosport (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: EFR32BG22C224F512GM40 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFR32BG22_DFP.4.4.0
  cpu: as above
  output: BG22_duosport
  AfterMake: C:\gnu\arm\10 2021.10\bin\arm-none-eabi-size "#L.elf" -A
  AfterMake: as above
target BG22_pinktens (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: EFR32BG22C224F512GM40 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFR32BG22_DFP.4.4.0
  cpu: as above
  output: BG22_pinktens
  AfterMake: C:\gnu\arm\10 2021.10\bin\arm-none-eabi-size "#L.elf" -A
  AfterMake: as above
target BG22_medtens (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: EFR32BG22C224F512GM40 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFR32BG22_DFP.4.4.0
  cpu: as above
  output: BG22_medtens
  AfterMake: C:\gnu\arm\10 2021.10\bin\arm-none-eabi-size "#L.elf" -A
  AfterMake: as above
