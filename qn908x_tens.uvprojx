# Keil uVision project qn908x_tens.uvprojx, settings and files
target 908X_bluetens (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: QN9080C NXP
  pack: NXP.QN908x_DFP.1.1.5
  cpu: IRAM(0x04000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QN908X_bluetens
  AfterMake: fromelf.exe --bin --output "..\_bin\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: QN908X,BLUETENS2
  c misc: --no_wchar
  c include: .\;.\bluetens2;..\ultracore\inc;..\qn908x\include;..\qn908x\;.\bluetens2\qn908x;..\qn908x\sdk;..\qn908x\sdk\bluetooth_1.5.7;..\qn908x\sdk\shim_dummy
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x4000000 size 0x20000
  scatter file: ../qn908x/linkscript/QN908x.sct
  group main
    ./: common_config.h fstab.h fstab.c loki.hpp loki.cpp main.cpp app.hpp app.cpp notification.h test_50hz.lok
  group shell
    ./sh/: shell.hpp shell.cpp shell.ctrl.cpp shell.ota.cpp shell.file.cpp
  group bluetens 2
    ./bluetens2/qn908x/: QN908X_config.h QN908X_porting.h
    ./bluetens2/: config.h ble.hpp bluetens2.cpp
  group qn908x
    ../qn908x/: QN908XC_startup.c QN908XC_system.c nxp.ble.cpp pmu.c adc.c trng.c calibration.c flexcomm.c fsp.c inpmux.c gpio.c radio.c rtc.c sct.c flash.c timer.c uart.c
    ../ultracore/src/core/: retarget.c
    ../ultracore/lib/: lib_ultracore_mdk_qn908x.lib
    ../qn908x/sdk/framework_5.6.8/Common/devices/QN908XC/mdk/: fw_symbols_mdk.h
